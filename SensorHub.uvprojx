# Keil uVision project SensorHub.uvprojx, settings and files
target SensorHUB (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Agri +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX,HSE_VALUE = 8000000
  c misc: --c99
  c include: .\User;.\Src;..\F4Lib\CMSIS\Device\ST\STM32F4xx\Include;..\F4Lib\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\F4Lib\STM32F4xx_StdPeriph_Driver\inc;.\Src\fatfs;.\Src\fatfs\option;.\Src\gsm;.\Src\hc05;.\Src\rf433;.\Src\rs232;.\Src\rs485;.\Src\ethernet\inc;.\Src\freemodbus\modbus;.\Src\freemodbus\modbus\ascii;.\Src\freemodbus\modbus\rtu;.\Src\freemodbus\modbus\tcp;.\Src\freemodbus\modbus\include;.\Src\freemodbus\port;.\Src\freemodbus;.\Src\sht1x;.\Src\bh1750;.\Src\bmp180;.\Src\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYS
    ../F4Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../F4Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c interrupt.h defines.h includes.h
    ./Src/: system_config.c
  group Src
    ./Src/: systick.c uart.c input.c output.c adc.c spi.c ringbuf.c m_time.c sys_time.c flash.c sensor.c jsmn.c i2c.c tracking.c SPIFlash.c db.c
  group Modbus
    ./Src/freemodbus/: mbhandler.c com.c comms.c
    ./Src/freemodbus/port/: portevent.c portserial.c porttimer.c
    ./Src/freemodbus/modbus/: mb.c
    ./Src/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./Src/freemodbus/modbus/ascii/: mbascii.c
    ./Src/freemodbus/modbus/tcp/: mbtcp.c
    ./Src/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group rs232
    ./Src/rs232/: rs232_com.c
  group rs485
    ./Src/rs485/: rs485_com.c
  group sdcard
    ./Src/fatfs/: ff.c sdcard.c fattime.c
  group gsm
    ./Src/gsm/: modem.c sim900.c at_command_parser.c gsm_handler.c
  group sht1x
    ./Src/sht1x/: sht1x.c
  group bmp180
    ./Src/bmp180/: bmp180.c
  group bh1750
    ./Src/bh1750/: bh1750.c
  group mqtt
    ./Src/mqtt/: GPRS_MQTTClient.c SIM900TCPClient.c
software components: CMSIS:CORE 4.3.0
